# Keil uVision project libdrivers.uvproj, settings and files
target nuttx_lib (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: drivers +hex (library)
  AfterMake: cmd /c mkdir "lib"
  AfterMake: cmd /c copy "$Llib@L.a" "lib\"
  group drivers
    ../../../../../drivers/bch/: bchlib_setup.c bchlib_teardown.c bchlib_read.c bchlib_write.c bchlib_cache.c bchlib_sem.c bchdev_register.c bchdev_unregister.c bchdev_driver.c
    ../../../../../drivers/i2c/: i2c_read.c i2c_write.c i2c_writeread.c
    ../../../../../drivers/loop/: losetup.c
    ../../../../../drivers/mtd/: at45db.c flash_eraseall.c ftl.c m25px.c ramtron.c mtd_config.c
    ../../../../../drivers/pipes/: pipe.c fifo.c pipe_common.c
    ../../../../../drivers/serial/: serial.c serial_io.c lowconsole.c
    ../../../../../drivers/usbhost/: hid_parser.c
    ../../../../../drivers/: dev_null.c dev_zero.c ramdisk.c
