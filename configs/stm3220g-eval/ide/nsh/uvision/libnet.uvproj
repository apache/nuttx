# Keil uVision project libnet.uvproj, settings and files
target nuttx_lib (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: net +hex (library)
  AfterMake: cmd /c mkdir "lib"
  AfterMake: cmd /c copy "$Llib@L.a" "lib\"
  group net
    ../../../../../net/socket/: bind.c connect.c getsockname.c recv.c recvfrom.c send.c sendto.c socket.c net_sockets.c net_close.c net_dupsd.c net_dupsd2.c net_clone.c net_poll.c net_vfcntl.c listen.c accept.c net_monitor.c setsockopt.c getsockopt.c net_timeo.c net_checksd.c
    ../../../../../net/tcp/: tcp_accept.c tcp_send_unbuffered.c tcp_conn.c tcp_seqno.c tcp_devpoll.c tcp_finddev.c tcp_timer.c tcp_send.c tcp_input.c tcp_appsend.c tcp_listen.c tcp_callback.c tcp_backlog.c tcp_ipselect.c
    ../../../../../net/netdev/: netdev_register.c netdev_ioctl.c netdev_txnotify.c netdev_findbyname.c netdev_findbyaddr.c netdev_findbyindex.c netdev_count.c netdev_foreach.c netdev_unregister.c netdev_carrier.c netdev_default.c netdev_verify.c
    ../../../../../net/: net_initialize.c
    ../../../../../net/iob/: iob_add_queue.c iob_alloc.c iob_alloc_qentry.c iob_clone.c iob_concat.c iob_copyin.c iob_copyout.c iob_contig.c iob_free.c iob_free_chain.c iob_free_qentry.c iob_free_queue.c iob_initialize.c iob_pack.c iob_peek_queue.c iob_remove_queue.c iob_trimhead.c iob_trimhead_queue.c iob_trimtail.c
    ../../../../../net/arp/: arp_arpin.c arp_out.c arp_format.c arp_table.c arp_timer.c
    ../../../../../net/icmp/: icmp_input.c icmp_ping.c icmp_poll.c icmp_send.c
    ../../../../../net/udp/: udp_psock_send.c udp_psock_sendto.c udp_conn.c udp_devpoll.c udp_send.c udp_input.c udp_finddev.c udp_callback.c udp_ipselect.c
    ../../../../../net/devif/: devif_initialize.c net_setipid.c devif_send.c devif_poll.c devif_callback.c ipv4_input.c devif_iobsend.c
    ../../../../../net/utils/: net_dsec2tick.c net_dsec2timeval.c net_timeval2dsec.c net_chksum.c
