# IAR project libmm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pe174
  ICCARM.IExtraOptions: --no_mem_idioms
  ICCARM.CCIncludePath2: ../../../../../mm; ../../../../../include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ASSEMBLY__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: template_nuttx_lib.bin
  ILINK.IlinkOutputFile: k103.out
  ILINK.IlinkIcfFile: stm32f207xG.icf
  ILINK.IlinkProgramEntryLabel: __start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group mm
    ../../../../../mm/mm_heap/: mm_initialize.c mm_sem.c mm_addfreechunk.c mm_size2ndx.c mm_shrinkchunk.c mm_brkaddr.c mm_calloc.c mm_extend.c mm_free.c mm_mallinfo.c mm_malloc.c mm_memalign.c mm_realloc.c mm_zalloc.c
    ../../../../../mm/umm_heap/: umm_initialize.c umm_addregion.c umm_sem.c umm_brkaddr.c umm_calloc.c umm_extend.c umm_free.c umm_mallinfo.c umm_malloc.c umm_memalign.c umm_realloc.c umm_zalloc.c umm_globals.c
