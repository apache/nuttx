# IAR project libarch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pe174
  ICCARM.IExtraOptions: --no_mem_idioms
  ICCARM.CCIncludePath2: ../../../../../arch/arm/src/chip; ../../../../../arch/arm/src; ../../../../../arch/arm/src/armv7-m; ../../../../../sched; ../../../../../arch/arm/src/common; ../../../../../include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ASSEMBLY__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: template_nuttx_lib.bin
  ILINK.IlinkOutputFile: k103.out
  ILINK.IlinkIcfFile: stm32f207xG.icf
  ILINK.IlinkProgramEntryLabel: __start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group src
    ../../../../../arch/arm/src/armv7-m/iar/: up_saveusercontext.S up_fullcontextrestore.S up_switchcontext.S up_testset.S vfork.S
    ../../../../../arch/arm/src/chip/: stm32_allocateheap.c stm32_start.c stm32_rcc.c stm32_lse.c stm32_lsi.c stm32_gpio.c stm32_exti_gpio.c stm32_flash.c stm32_irq.c stm32_dma.c stm32_lowputc.c stm32_serial.c stm32_spi.c stm32_sdio.c stm32_tim.c stm32_waste.c stm32_ccm.c stm32_uid.c stm32_capture.c stm32_timerisr.c stm32_i2c.c stm32_idle.c stm32_pmstop.c stm32_pmstandby.c stm32_pmsleep.c stm32_pminitialize.c stm32_eth.c stm32_pwr.c stm32_exti_pwr.c stm32_rtc.c
    ../../../../../arch/arm/src/armv7-m/: up_assert.c up_blocktask.c up_copyfullstate.c up_initialstate.c up_memfault.c up_releasepending.c up_reprioritizertr.c up_schedulesigaction.c up_sigdeliver.c up_systemreset.c up_unblocktask.c up_doirq.c up_hardfault.c up_svcall.c
    ../../../../../arch/arm/src/common/: up_createstack.c up_mdelay.c up_udelay.c up_exit.c up_initialize.c up_interruptcontext.c up_modifyreg8.c up_modifyreg16.c up_modifyreg32.c up_releasestack.c up_stackframe.c up_usestack.c up_vfork.c
