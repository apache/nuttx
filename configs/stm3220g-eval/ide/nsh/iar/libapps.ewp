# IAR project libapps.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pe174
  ICCARM.IExtraOptions: --no_mem_idioms
  ICCARM.CCIncludePath2: ../../../../../../apps/nshlib; ../../../../../../apps/system/readline; ../../../../../../apps/netutils/netlib; ../../../../../include; ../../../../../../apps/builtin; ../../../../../../apps/examples/nsh; ../../../../../../apps/netutils/webclient; ../../../../../../apps/netutils/tftpc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ASSEMBLY__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: template_nuttx_lib.bin
  ILINK.IlinkOutputFile: k103.out
  ILINK.IlinkIcfFile: stm32f207xG.icf
  ILINK.IlinkProgramEntryLabel: __start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group apps
    ../../../../../../apps/builtin/: builtin_forindex.c builtin_list.c exec_builtin.c
    ../../../../../../apps/examples/nsh/: nsh_main.c
    ../../../../../../apps/netutils/tftpc/: tftpc_get.c tftpc_put.c tftpc_packets.c
    ../../../../../../apps/netutils/netlib/: netlib_ipv4addrconv.c netlib_ethaddrconv.c netlib_parsehttpurl.c netlib_setifstatus.c netlib_getifstatus.c netlib_setipv4addr.c netlib_getipv4addr.c netlib_setdripv4addr.c netlib_setipv4netmask.c netlib_getdripv4addr.c netlib_getipv4netmask.c netlib_getarp.c netlib_setarp.c netlib_delarp.c netlib_setipv4dnsaddr.c netlib_server.c netlib_listenon.c netlib_setmacaddr.c netlib_getmacaddr.c
    ../../../../../../apps/netutils/webclient/: webclient.c
    ../../../../../../apps/nshlib/: nsh_init.c nsh_parse.c nsh_console.c nsh_script.c nsh_command.c nsh_fscmds.c nsh_ddcmd.c nsh_proccmds.c nsh_mmcmds.c nsh_timcmds.c nsh_envcmds.c nsh_syscmds.c nsh_dbgcmds.c nsh_session.c nsh_fsutils.c nsh_builtin.c nsh_netinit.c nsh_netcmds.c nsh_mntcmds.c nsh_consolemain.c nsh_test.c
    ../../../../../../apps/system/readline/: readline_common.c readline.c
