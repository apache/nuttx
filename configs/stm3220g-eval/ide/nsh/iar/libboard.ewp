# IAR project libboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pe174
  ICCARM.IExtraOptions: --no_mem_idioms
  ICCARM.CCIncludePath2: ../../../../../include; ../../../../../arch/arm/src/board; ../../../../../arch/arm/src/armv7-m; ../../../../../sched; ../../../../../arch/arm/src/common; ../../../../../arch/arm/src/chip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ASSEMBLY__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: template_nuttx_lib.bin
  ILINK.IlinkOutputFile: k103.out
  ILINK.IlinkIcfFile: stm32f207xG.icf
  ILINK.IlinkProgramEntryLabel: __start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board
    ../../../../../arch/arm/src/board/: stm32_boot.c stm32_spi.c stm32_autoleds.c
