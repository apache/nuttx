# IAR project libsched.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pe174
  ICCARM.IExtraOptions: --no_mem_idioms
  ICCARM.CCIncludePath2: ../../../../../sched; ../../../../../include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ASSEMBLY__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: template_nuttx_lib.bin
  ILINK.IlinkOutputFile: k103.out
  ILINK.IlinkIcfFile: stm32f207xG.icf
  ILINK.IlinkProgramEntryLabel: __start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group sched
    ../../../../../sched/clock/: clock_initialize.c clock_settime.c clock_gettime.c clock_getres.c clock_time2ticks.c clock_abstime2ticks.c clock_ticks2time.c clock_systimer.c clock_systimespec.c clock_timespec_add.c clock_timespec_subtract.c
    ../../../../../sched/errno/: errno_getptr.c
    ../../../../../sched/environ/: env_getenvironptr.c env_dup.c env_release.c env_findvar.c env_removevar.c env_clearenv.c env_getenv.c env_putenv.c env_setenv.c env_unsetenv.c
    ../../../../../sched/group/: group_create.c group_join.c group_leave.c group_find.c group_setupstreams.c group_setupidlefiles.c group_setuptaskfiles.c group_foreachchild.c group_killchildren.c group_waiter.c group_signal.c
    ../../../../../sched/init/: os_start.c os_bringup.c
    ../../../../../sched/irq/: irq_initialize.c irq_attach.c irq_dispatch.c irq_unexpectedisr.c
    ../../../../../sched/mqueue/: mq_send.c mq_timedsend.c mq_sndinternal.c mq_receive.c mq_timedreceive.c mq_rcvinternal.c mq_initialize.c mq_descreate.c mq_desclose.c mq_msgfree.c mq_msgqalloc.c mq_msgqfree.c mq_release.c mq_recover.c mq_setattr.c mq_getattr.c mq_waitirq.c mq_notify.c
    ../../../../../sched/paging/: pg_miss.c pg_worker.c
    ../../../../../sched/pthread/: pthread_create.c pthread_exit.c pthread_join.c pthread_detach.c pthread_yield.c pthread_getschedparam.c pthread_setschedparam.c pthread_mutexinit.c pthread_mutexdestroy.c pthread_mutexlock.c pthread_mutextrylock.c pthread_mutexunlock.c pthread_condinit.c pthread_conddestroy.c pthread_condwait.c pthread_condsignal.c pthread_condbroadcast.c pthread_barrierinit.c pthread_barrierdestroy.c pthread_barrierwait.c pthread_cancel.c pthread_setcancelstate.c pthread_keycreate.c pthread_setspecific.c pthread_getspecific.c pthread_keydelete.c pthread_initialize.c pthread_completejoin.c pthread_findjoininfo.c pthread_once.c pthread_release.c pthread_setschedprio.c pthread_condtimedwait.c pthread_kill.c pthread_sigmask.c
    ../../../../../sched/sched/: sched_garbage.c sched_getfiles.c sched_addreadytorun.c sched_removereadytorun.c sched_addprioritized.c sched_mergeprioritized.c sched_mergepending.c sched_addblocked.c sched_removeblocked.c sched_free.c sched_gettcb.c sched_verifytcb.c sched_releasetcb.c sched_getsockets.c sched_getstreams.c sched_setparam.c sched_setpriority.c sched_getparam.c sched_setscheduler.c sched_getscheduler.c sched_yield.c sched_rrgetinterval.c sched_foreach.c sched_lock.c sched_unlock.c sched_lockcount.c sched_self.c sched_waitpid.c sched_roundrobin.c sched_resumescheduler.c sched_processtimer.c
    ../../../../../sched/semaphore/: sem_destroy.c sem_wait.c sem_trywait.c sem_tickwait.c sem_timedwait.c sem_timeout.c sem_post.c sem_recover.c sem_reset.c sem_waitirq.c
    ../../../../../sched/signal/: sig_initialize.c sig_action.c sig_procmask.c sig_pending.c sig_suspend.c sig_kill.c sig_queue.c sig_waitinfo.c sig_timedwait.c sig_findaction.c sig_allocatependingsigaction.c sig_releasependingsigaction.c sig_unmaskpendingsignal.c sig_removependingsignal.c sig_releasependingsignal.c sig_lowest.c sig_mqnotempty.c sig_cleanup.c sig_dispatch.c sig_deliver.c sig_pause.c sig_nanosleep.c
    ../../../../../sched/task/: task_create.c task_init.c task_setup.c task_activate.c task_start.c task_delete.c task_exit.c task_exithook.c task_recover.c task_restart.c task_spawnparms.c task_terminate.c task_getgroup.c task_prctl.c task_getpid.c exit.c task_vfork.c task_spawn.c
    ../../../../../sched/timer/: timer_initialize.c timer_create.c timer_delete.c timer_getoverrun.c timer_gettime.c timer_settime.c timer_release.c
    ../../../../../sched/wdog/: wd_initialize.c wd_create.c wd_start.c wd_cancel.c wd_delete.c wd_gettime.c wd_recover.c
