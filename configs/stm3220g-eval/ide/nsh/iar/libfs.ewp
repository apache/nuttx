# IAR project libfs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pe174
  ICCARM.IExtraOptions: --no_mem_idioms
  ICCARM.CCIncludePath2: ../../../../../fs; ../../../../../include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ASSEMBLY__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: template_nuttx_lib.bin
  ILINK.IlinkOutputFile: k103.out
  ILINK.IlinkIcfFile: stm32f207xG.icf
  ILINK.IlinkProgramEntryLabel: __start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group fs
    ../../../../../fs/: fs_initialize.c
    ../../../../../fs/inode/: fs_files.c fs_foreachinode.c fs_inode.c fs_inodeaddref.c fs_inodebasename.c fs_inodefind.c fs_inoderelease.c fs_inoderemove.c fs_inodereserve.c
    ../../../../../fs/vfs/: fs_close.c fs_dup.c fs_dup2.c fs_fcntl.c fs_dupfd.c fs_dupfd2.c fs_epoll.c fs_getfilep.c fs_ioctl.c fs_lseek.c fs_mkdir.c fs_open.c fs_poll.c fs_read.c fs_rename.c fs_rmdir.c fs_stat.c fs_statfs.c fs_select.c fs_unlink.c fs_write.c fs_fsync.c fs_pread.c fs_pwrite.c fs_fdopen.c
    ../../../../../fs/driver/: fs_registerdriver.c fs_unregisterdriver.c fs_registerblockdriver.c fs_unregisterblockdriver.c fs_findblockdriver.c fs_openblockdriver.c fs_closeblockdriver.c fs_blockproxy.c
    ../../../../../fs/dirent/: fs_closedir.c fs_opendir.c fs_readdir.c fs_rewinddir.c fs_seekdir.c
    ../../../../../fs/mmap/: fs_mmap.c
    ../../../../../fs/mqueue/: mq_open.c mq_close.c mq_unlink.c
    ../../../../../fs/mount/: fs_mount.c fs_umount2.c fs_foreachmountpoint.c
    ../../../../../fs/fat/: fs_fat32.c fs_fat32dirent.c fs_fat32attrib.c fs_fat32util.c
