# IAR project libc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pe174
  ICCARM.IExtraOptions: --no_mem_idioms
  ICCARM.CCIncludePath2: ../../../../../libc; ../../../../../include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ASSEMBLY__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: template_nuttx_lib.bin
  ILINK.IlinkOutputFile: k103.out
  ILINK.IlinkIcfFile: stm32f207xG.icf
  ILINK.IlinkProgramEntryLabel: __start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group libc
    ../../../../../libc/dirent/: lib_readdirr.c lib_telldir.c
    ../../../../../libc/fixedmath/: lib_fixedmath.c lib_b16sin.c lib_b16cos.c lib_b16atan2.c
    ../../../../../libc/libgen/: lib_basename.c lib_dirname.c
    ../../../../../libc/misc/: lib_stream.c lib_filesem.c lib_utsname.c lib_tea_encrypt.c lib_tea_decrypt.c lib_umul32.c lib_umul64.c lib_umul32x64.c lib_uadd32x64.c lib_uadd64.c lib_usub64x32.c lib_usub64.c lib_sendfile.c lib_streamsem.c lib_match.c lib_crc32.c lib_crc16.c lib_crc8.c lib_dumpbuffer.c
    ../../../../../libc/net/: lib_addrconfig.c lib_etherntoa.c lib_htons.c lib_htonl.c lib_inetaddr.c lib_inetntoa.c lib_inetntop.c lib_inetpton.c lib_shutdown.c
    ../../../../../libc/netdb/: lib_netdb.c lib_gethostbyname.c lib_gethostbynamer.c lib_dnsinit.c lib_dnsbind.c lib_dnsquery.c lib_dnsaddserver.c lib_dnsforeach.c lib_dnscache.c
    ../../../../../libc/pthread/: pthread_attrinit.c pthread_attrdestroy.c pthread_attrsetschedpolicy.c pthread_attrgetschedpolicy.c pthread_attrsetinheritsched.c pthread_attrgetinheritsched.c pthread_attrsetstacksize.c pthread_attrgetstacksize.c pthread_attrsetschedparam.c pthread_attrgetschedparam.c pthread_barrierattrinit.c pthread_barrierattrdestroy.c pthread_barrierattrgetpshared.c pthread_barrierattrsetpshared.c pthread_condattrinit.c pthread_condattrdestroy.c pthread_mutexattrinit.c pthread_mutexattrdestroy.c pthread_mutexattrgetpshared.c pthread_mutexattrsetpshared.c
    ../../../../../libc/queue/: sq_addlast.c sq_addfirst.c sq_addafter.c sq_cat.c sq_rem.c sq_remlast.c sq_remfirst.c sq_remafter.c dq_addlast.c dq_addfirst.c dq_addafter.c dq_addbefore.c dq_cat.c dq_rem.c dq_remlast.c dq_remfirst.c
    ../../../../../libc/sched/: sched_getprioritymax.c sched_getprioritymin.c
    ../../../../../libc/semaphore/: sem_init.c sem_getvalue.c
    ../../../../../libc/signal/: sig_emptyset.c sig_fillset.c sig_addset.c sig_delset.c sig_ismember.c sig_hold.c sig_relse.c sig_ignore.c sig_pause.c sig_set.c
    ../../../../../libc/spawn/: lib_psfa_addaction.c lib_psfa_addclose.c lib_psfa_adddup2.c lib_psfa_addopen.c lib_psfa_destroy.c lib_psfa_init.c lib_psa_getflags.c lib_psa_getschedparam.c lib_psa_getschedpolicy.c lib_psa_init.c lib_psa_setflags.c lib_psa_setschedparam.c lib_psa_setschedpolicy.c lib_psa_getsigmask.c lib_psa_setsigmask.c lib_psa_getstacksize.c lib_psa_setstacksize.c
    ../../../../../libc/stdio/: lib_fileno.c lib_printf.c lib_sprintf.c lib_asprintf.c lib_snprintf.c lib_libsprintf.c lib_vsprintf.c lib_vasprintf.c lib_vsnprintf.c lib_libvsprintf.c lib_dprintf.c lib_vdprintf.c lib_meminstream.c lib_memoutstream.c lib_memsistream.c lib_memsostream.c lib_lowoutstream.c lib_zeroinstream.c lib_nullinstream.c lib_nulloutstream.c lib_sscanf.c lib_rawinstream.c lib_rawoutstream.c lib_rawsistream.c lib_rawsostream.c lib_fopen.c lib_freopen.c lib_fclose.c lib_fread.c lib_libfread.c lib_fseek.c lib_ftell.c lib_fsetpos.c lib_fgetpos.c lib_fgetc.c lib_fgets.c lib_gets_s.c lib_gets.c lib_libfgets.c lib_fwrite.c lib_libfwrite.c lib_fflush.c lib_libflushall.c lib_libfflush.c lib_rdflush.c lib_wrflush.c lib_fputc.c lib_puts.c lib_fputs.c lib_ungetc.c lib_vprintf.c lib_fprintf.c lib_vfprintf.c lib_stdinstream.c lib_stdoutstream.c lib_stdsistream.c lib_stdsostream.c lib_perror.c lib_feof.c lib_ferror.c lib_clearerr.c lib_tempnam.c lib_tmpnam.c lib_libnoflush.c lib_libsnoflush.c
    ../../../../../libc/stdlib/: lib_abs.c lib_abort.c lib_div.c lib_ldiv.c lib_lldiv.c lib_imaxabs.c lib_itoa.c lib_labs.c lib_llabs.c lib_bsearch.c lib_rand.c lib_qsort.c lib_strtol.c lib_strtoll.c lib_strtoul.c lib_strtoull.c lib_strtod.c lib_checkbase.c lib_mktemp.c lib_mkstemp.c
    ../../../../../libc/string/: lib_isbasedigit.c lib_memset.c lib_memchr.c lib_memccpy.c lib_memcmp.c lib_memmove.c lib_skipspace.c lib_stpcpy.c lib_strcasecmp.c lib_strcat.c lib_strchr.c lib_strcpy.c lib_strcmp.c lib_strcspn.c lib_strdup.c lib_strerror.c lib_strlen.c lib_strnlen.c lib_strncasecmp.c lib_strncat.c lib_strncmp.c lib_strncpy.c lib_strndup.c lib_strcasestr.c lib_strpbrk.c lib_strrchr.c lib_strspn.c lib_strstr.c lib_strtok.c lib_strtokr.c lib_memcpy.c
    ../../../../../libc/symtab/: symtab_findbyname.c symtab_findbyvalue.c symtab_findorderedbyname.c symtab_findorderedbyvalue.c
    ../../../../../libc/syslog/: lib_syslog.c lib_setlogmask.c
    ../../../../../libc/time/: lib_strftime.c lib_calendar2utc.c lib_daysbeforemonth.c lib_gettimeofday.c lib_isleapyear.c lib_settimeofday.c lib_time.c lib_mktime.c lib_gmtime.c lib_gmtimer.c
    ../../../../../libc/unistd/: lib_access.c lib_getopt.c lib_getoptargp.c lib_getoptindp.c lib_getoptoptp.c lib_chdir.c lib_getcwd.c lib_sleep.c lib_usleep.c lib_gethostname.c lib_sethostname.c
