# IAR project nuttx_main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pe174
  ICCARM.IExtraOptions: --no_mem_idioms
  ICCARM.CCIncludePath2: ../../../../../arch/arm/src/chip; ../../../../../arch/arm/src; ../../../../../arch/arm/src/armv7-m; ../../../../../sched; ../../../../../arch/arm/src/common; ../../../../../include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ASSEMBLY__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: template_nuttx_main.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\scripts\stm32f207xG.icf
  ILINK.IlinkProgramEntryLabel: __start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group gnu
    ../../../../../arch/arm/src/chip/iar/: stm32_vectors.S
  group libs
    libboard/Obj/: libboard.a
    libmm/Obj/: libmm.a
    libfs/Obj/: libfs.a
    libdrivers/Obj/: libdrivers.a
    libarch/Obj/: libarch.a
    libbinfmt/Obj/: libbinfmt.a
    libsched/Obj/: libsched.a
    libapps/Obj/: libapps.a
    libc/Obj/: libc.a
    libnet/Obj/: libnet.a
