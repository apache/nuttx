# IAR project libbinfmt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pe174
  ICCARM.IExtraOptions: --no_mem_idioms
  ICCARM.CCIncludePath2: ../../../../../include; ../../../../../sched; ../../../../../binfmt
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ASSEMBLY__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: template_nuttx_lib.bin
  ILINK.IlinkOutputFile: k103.out
  ILINK.IlinkIcfFile: stm32f207xG.icf
  ILINK.IlinkProgramEntryLabel: __start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group binfmt
    ../../../../../binfmt/: binfmt_globals.c binfmt_register.c binfmt_unregister.c binfmt_loadmodule.c binfmt_unloadmodule.c binfmt_execmodule.c binfmt_exec.c binfmt_copyargv.c binfmt_dumpmodule.c builtin.c
    ../../../../../binfmt/libbuiltin/: libbuiltin_getname.c libbuiltin_isavail.c
