# IAR project libdrivers.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pe174
  ICCARM.IExtraOptions: --no_mem_idioms
  ICCARM.CCIncludePath2: ../../../../../drivers/bch; ../../../../../drivers; ../../../../../drivers/i2c; ../../../../../drivers/mmcsd; ../../../../../drivers/loop; ../../../../../drivers/usbhost; ../../../../../include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ASSEMBLY__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: template_nuttx_lib.bin
  ILINK.IlinkOutputFile: k103.out
  ILINK.IlinkIcfFile: stm32f207xG.icf
  ILINK.IlinkProgramEntryLabel: __start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group drivers
    ../../../../../drivers/bch/: bchlib_setup.c bchlib_teardown.c bchlib_read.c bchlib_write.c bchlib_cache.c bchlib_sem.c bchdev_register.c bchdev_unregister.c bchdev_driver.c
    ../../../../../drivers/i2c/: i2c_read.c i2c_write.c i2c_writeread.c
    ../../../../../drivers/loop/: losetup.c
    ../../../../../drivers/mtd/: at45db.c flash_eraseall.c ftl.c m25px.c ramtron.c mtd_config.c
    ../../../../../drivers/pipes/: pipe.c fifo.c pipe_common.c
    ../../../../../drivers/serial/: serial.c serial_io.c lowconsole.c
    ../../../../../drivers/usbhost/: hid_parser.c
    ../../../../../drivers/: dev_null.c dev_zero.c ramdisk.c
