<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libapps.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\template_nuttx_lib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\template_nuttx_main.ewp</path>
  </project>
  <batchBuild/>
</workspace>


