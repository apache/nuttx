# Keil uVision project template_nuttx_lib.uvproj, settings and files
target nuttx_lib (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: nuttx +hex (library)
  AfterMake: cmd /c mkdir "lib"
  AfterMake: cmd /c copy "$Llib@L.a" "lib\"
  group gnu
    ../../../arch/arm/src/chip/gnu/: stm32_vectors.S
