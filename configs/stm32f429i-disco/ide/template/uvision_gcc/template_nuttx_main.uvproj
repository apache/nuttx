# Keil uVision project template_nuttx_main.uvproj, settings and files
target nuttx (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: nuttx +hex
  group gnu
    ../../../arch/arm/src/chip/gnu/: stm32_vectors.S
