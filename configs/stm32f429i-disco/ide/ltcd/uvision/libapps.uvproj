# Keil uVision project libapps.uvproj, settings and files
target nuttx_lib (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: apps +hex (library)
  AfterMake: cmd /c mkdir "lib"
  AfterMake: cmd /c copy "$Llib@L.a" "lib\"
  group apps
    ../../../../../../apps/builtin/: builtin_forindex.c builtin_list.c exec_builtin.c
    ../../../../../../apps/examples/ltdc/: dma2d.c ltdc_main.c
    ../../../../../../apps/examples/nsh/: nsh_main.c
    ../../../../../../apps/examples/nx/: nx_events.c nx_kbdin.c nx_main.c
    ../../../../../../apps/nshlib/: nsh_init.c nsh_parse.c nsh_console.c nsh_script.c nsh_command.c nsh_fscmds.c nsh_ddcmd.c nsh_proccmds.c nsh_mmcmds.c nsh_timcmds.c nsh_envcmds.c nsh_syscmds.c nsh_dbgcmds.c nsh_session.c nsh_fsutils.c nsh_builtin.c nsh_mntcmds.c nsh_consolemain.c nsh_test.c
    ../../../../../../apps/platform/board/: stm32_cxxinitialize.c
    ../../../../../../apps/system/readline/: readline_common.c readline.c
