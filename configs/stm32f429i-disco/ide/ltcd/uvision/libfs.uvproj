# Keil uVision project libfs.uvproj, settings and files
target nuttx_lib (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: fs +hex (library)
  AfterMake: cmd /c mkdir "lib"
  AfterMake: cmd /c copy "$Llib@L.a" "lib\"
  group fs
    ../../../../../fs/: fs_initialize.c
    ../../../../../fs/inode/: fs_files.c fs_foreachinode.c fs_inode.c fs_inodeaddref.c fs_inodebasename.c fs_inodefind.c fs_inoderelease.c fs_inoderemove.c fs_inodereserve.c
    ../../../../../fs/vfs/: fs_close.c fs_dup.c fs_dup2.c fs_fcntl.c fs_dupfd.c fs_dupfd2.c fs_epoll.c fs_getfilep.c fs_ioctl.c fs_lseek.c fs_mkdir.c fs_open.c fs_poll.c fs_read.c fs_rename.c fs_rmdir.c fs_stat.c fs_statfs.c fs_select.c fs_unlink.c fs_write.c fs_fsync.c fs_pread.c fs_pwrite.c fs_fdopen.c
    ../../../../../fs/driver/: fs_registerdriver.c fs_unregisterdriver.c fs_registerblockdriver.c fs_unregisterblockdriver.c fs_findblockdriver.c fs_openblockdriver.c fs_closeblockdriver.c fs_blockproxy.c
    ../../../../../fs/dirent/: fs_closedir.c fs_opendir.c fs_readdir.c fs_rewinddir.c fs_seekdir.c
    ../../../../../fs/mmap/: fs_mmap.c
    ../../../../../fs/mqueue/: mq_open.c mq_close.c mq_unlink.c
    ../../../../../fs/mount/: fs_mount.c fs_umount2.c fs_foreachmountpoint.c
    ../../../../../fs/procfs/: fs_procfs.c fs_procfsutil.c fs_procfsproc.c fs_procfsuptime.c fs_procfscpuload.c fs_procfskmm.c
