# Keil uVision project libcxx.uvproj, settings and files
target nuttx_lib (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: cxx +hex (library)
  AfterMake: cmd /c mkdir "lib"
  AfterMake: cmd /c copy "$Llib@L.a" "lib\"
  group libxx
    ../../../../../libxx/: libxx_cxapurevirtual.cxx libxx_eabi_atexit.cxx libxx_cxa_atexit.cxx libxx_delete.cxx libxx_deletea.cxx libxx_new.cxx libxx_newa.cxx libxx_stdthrow.cxx libxx_cxa_guard.cxx
