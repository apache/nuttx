# Keil uVision project libmm.uvproj, settings and files
target nuttx_lib (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: mm +hex (library)
  AfterMake: cmd /c mkdir "lib"
  AfterMake: cmd /c copy "$Llib@L.a" "lib\"
  group mm
    ../../../../../mm/mm_heap/: mm_initialize.c mm_sem.c mm_addfreechunk.c mm_size2ndx.c mm_shrinkchunk.c mm_brkaddr.c mm_calloc.c mm_extend.c mm_free.c mm_mallinfo.c mm_malloc.c mm_memalign.c mm_realloc.c mm_zalloc.c
    ../../../../../mm/umm_heap/: umm_initialize.c umm_addregion.c umm_sem.c umm_brkaddr.c umm_calloc.c umm_extend.c umm_free.c umm_mallinfo.c umm_malloc.c umm_memalign.c umm_realloc.c umm_zalloc.c umm_globals.c
