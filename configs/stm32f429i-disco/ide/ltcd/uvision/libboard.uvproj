# Keil uVision project libboard.uvproj, settings and files
target nuttx_lib (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: board +hex (library)
  AfterMake: cmd /c mkdir "lib"
  AfterMake: cmd /c copy "$Llib@L.a" "lib\"
  group board
    ../../../../../arch/arm/src/board/: stm32_boot.c stm32_spi.c stm32_autoleds.c stm32_buttons.c stm32_appinit.c stm32_extmem.c stm32_ili93414ws.c stm32_lcd.c
