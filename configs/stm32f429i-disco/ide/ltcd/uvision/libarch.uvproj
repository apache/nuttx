# Keil uVision project libarch.uvproj, settings and files
target nuttx_lib (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: arch +hex (library)
  AfterMake: cmd /c mkdir "lib"
  AfterMake: cmd /c copy "$Llib@L.a" "lib\"
  group src
    ../../../../../arch/arm/src/armv7-m/gnu/: up_saveusercontext.S up_fullcontextrestore.S up_switchcontext.S up_testset.S vfork.S
    ../../../../../arch/arm/src/chip/: stm32_allocateheap.c stm32_start.c stm32_rcc.c stm32_lse.c stm32_lsi.c stm32_gpio.c stm32_exti_gpio.c stm32_flash.c stm32_irq.c stm32_dma.c stm32_lowputc.c stm32_serial.c stm32_spi.c stm32_sdio.c stm32_tim.c stm32_waste.c stm32_ccm.c stm32_uid.c stm32_capture.c stm32_timerisr.c stm32_procfs_ccm.c stm32_i2c.c stm32_idle.c stm32_pmstop.c stm32_pmstandby.c stm32_pmsleep.c stm32_pminitialize.c stm32_pwr.c stm32_exti_pwr.c stm32_ltdc.c stm32_dma2d.c stm32_dumpgpio.c
    ../../../../../arch/arm/src/armv7-m/: up_assert.c up_blocktask.c up_copyfullstate.c up_initialstate.c up_memfault.c up_releasepending.c up_reprioritizertr.c up_schedulesigaction.c up_sigdeliver.c up_systemreset.c up_unblocktask.c up_doirq.c up_hardfault.c up_svcall.c
    ../../../../../arch/arm/src/common/: up_createstack.c up_mdelay.c up_udelay.c up_exit.c up_initialize.c up_interruptcontext.c up_modifyreg8.c up_modifyreg16.c up_modifyreg32.c up_releasestack.c up_stackframe.c up_usestack.c up_vfork.c
