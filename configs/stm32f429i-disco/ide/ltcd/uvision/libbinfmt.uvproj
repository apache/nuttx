# Keil uVision project libbinfmt.uvproj, settings and files
target nuttx_lib (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: binfmt +hex (library)
  AfterMake: cmd /c mkdir "lib"
  AfterMake: cmd /c copy "$Llib@L.a" "lib\"
  group binfmt
    ../../../../../binfmt/: binfmt_globals.c binfmt_register.c binfmt_unregister.c binfmt_loadmodule.c binfmt_unloadmodule.c binfmt_execmodule.c binfmt_exec.c binfmt_copyargv.c binfmt_dumpmodule.c builtin.c
    ../../../../../binfmt/libbuiltin/: libbuiltin_getname.c libbuiltin_isavail.c
