# Keil uVision project libnx.uvproj, settings and files
target nuttx_lib (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: nx +hex (library)
  AfterMake: cmd /c mkdir "lib"
  AfterMake: cmd /c copy "$Llib@L.a" "lib\"
  group libnx
    ../../../../../libnx/nxglib/: nxglib_circlepts.c nxglib_circletraps.c nxglib_intersecting.c nxglib_nonintersecting.c nxglib_nullrect.c nxglib_rectadd.c nxglib_rectcopy.c nxglib_rectinside.c nxglib_rectintersect.c nxglib_rectoffset.c nxglib_rectoverlap.c nxglib_rectsize.c nxglib_rectunion.c nxglib_rgb2yuv.c nxglib_rgbblend.c nxglib_runcopy.c nxglib_runoffset.c nxglib_splitline.c nxglib_trapcopy.c nxglib_trapoffset.c nxglib_vectoradd.c nxglib_vectsubtract.c nxglib_yuv2rgb.c
    ../../../../../libnx/nx/: nx_drawcircle.c nx_drawline.c nx_fillcircle.c
    ../../../../../libnx/nxfonts/: nxfonts_getfont.c nxfonts_convert_1bpp.c nxfonts_convert_2bpp.c nxfonts_convert_4bpp.c nxfonts_convert_8bpp.c nxfonts_convert_16bpp.c nxfonts_convert_24bpp.c nxfonts_convert_32bpp.c nxfonts_bitmaps_mono5x8.c
    ../../../../../libnx/nxtk/: nxtk_openwindow.c nxtk_closewindow.c nxtk_getposition.c nxtk_setposition.c nxtk_setsize.c nxtk_raise.c nxtk_lower.c nxtk_fillwindow.c nxtk_getwindow.c nxtk_filltrapwindow.c nxtk_movewindow.c nxtk_bitmapwindow.c nxtk_events.c nxtk_setsubwindows.c nxtk_drawcirclewindow.c nxtk_drawlinewindow.c nxtk_fillcirclewindow.c nxtk_block.c nxtk_opentoolbar.c nxtk_closetoolbar.c nxtk_filltoolbar.c nxtk_gettoolbar.c nxtk_filltraptoolbar.c nxtk_movetoolbar.c nxtk_bitmaptoolbar.c nxtk_drawcircletoolbar.c nxtk_drawlinetoolbar.c nxtk_fillcircletoolbar.c nxtk_toolbarbounds.c nxtk_subwindowclip.c nxtk_containerclip.c nxtk_subwindowmove.c nxtk_drawframe.c
