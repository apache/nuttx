# Keil uVision project libgraphics.uvproj, settings and files
target nuttx_lib (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: graphics +hex (library)
  AfterMake: cmd /c mkdir "lib"
  AfterMake: cmd /c copy "$Llib@L.a" "lib\"
  group graphics
    ../../../../../graphics/nxglib/: nxglib_setpixel_1bpp.c nxglib_setpixel_2bpp.c nxglib_setpixel_4bpp.c nxglib_setpixel_8bpp.c nxglib_setpixel_16bpp.c nxglib_setpixel_24bpp.c nxglib_setpixel_32bpp.c nxglib_fillrectangle_1bpp.c nxglib_fillrectangle_2bpp.c nxglib_fillrectangle_4bpp.c nxglib_fillrectangle_8bpp.c nxglib_fillrectangle_16bpp.c nxglib_fillrectangle_24bpp.c nxglib_fillrectangle_32bpp.c nxglib_getrectangle_1bpp.c nxglib_getrectangle_2bpp.c nxglib_getrectangle_4bpp.c nxglib_getrectangle_8bpp.c nxglib_getrectangle_16bpp.c nxglib_getrectangle_24bpp.c nxglib_getrectangle_32bpp.c nxglib_filltrapezoid_1bpp.c nxglib_filltrapezoid_2bpp.c nxglib_filltrapezoid_4bpp.c nxglib_filltrapezoid_8bpp.c nxglib_filltrapezoid_16bpp.c nxglib_filltrapezoid_24bpp.c nxglib_filltrapezoid_32bpp.c nxglib_moverectangle_1bpp.c nxglib_moverectangle_2bpp.c nxglib_moverectangle_4bpp.c nxglib_moverectangle_8bpp.c nxglib_moverectangle_16bpp.c nxglib_moverectangle_24bpp.c nxglib_moverectangle_32bpp.c nxglib_copyrectangle_1bpp.c nxglib_copyrectangle_2bpp.c nxglib_copyrectangle_4bpp.c nxglib_copyrectangle_8bpp.c nxglib_copyrectangle_16bpp.c nxglib_copyrectangle_24bpp.c nxglib_copyrectangle_32bpp.c
    ../../../../../graphics/nxbe/: nxbe_bitmap.c nxbe_configure.c nxbe_colormap.c nxbe_clipper.c nxbe_closewindow.c nxbe_fill.c nxbe_filltrapezoid.c nxbe_getrectangle.c nxbe_lower.c nxbe_move.c nxbe_raise.c nxbe_redraw.c nxbe_redrawbelow.c nxbe_setpixel.c nxbe_setposition.c nxbe_setsize.c nxbe_visible.c
    ../../../../../graphics/nxsu/: nx_bitmap.c nx_closewindow.c nx_fill.c nx_filltrapezoid.c nx_getposition.c nx_getrectangle.c nx_kbdchin.c nx_kbdin.c nx_lower.c nx_mousein.c nx_move.c nx_openwindow.c nx_raise.c nx_redrawreq.c nx_releasebkgd.c nx_requestbkgd.c nx_setpixel.c nx_setsize.c nx_setbgcolor.c nx_setposition.c nx_constructwindow.c nxsu_redrawreq.c nxsu_reportposition.c
